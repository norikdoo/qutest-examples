# Keil uVision project blinky.uvprojx, settings and files
target Target 1 (6180000::V6.18::ARMCLANG)
  device: STM32L053R8Tx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: blinky
  BeforeMake: cmd /c "del .\dbg\qstamp.o"
  AfterMake: fromelf --bin --output Objects/Blinky.bin Objects/Blinky.axf
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: Q_SPY Q_UTEST
  c include: src;test;..\..\..\include;..\..\..\ports\arm-cm\qv\armclang;..\..\..\3rd_party\CMSIS\Include;..\..\..\3rd_party\nucleo-l053r8;..\..\..\3rd_party\nucleo-l053r8\qutest;..\..\..\3rd_party\CMSIS\Include;..\..\..\src\qs;..\..\..\src\qf
  asm define: Stack_Size=2048 Heap_Size=16
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  link misc: --entry Reset_Handler
  group src
    ./src/: blinky.c blinky.h bsp.c bsp.h
    ./test/: test_blinky.c
  group QP
    ../../../src/qf/: qep_hsm.c qep_msm.c qf_act.c qf_actq.c qf_defer.c qf_dyn.c qf_mem.c qf_ps.c qf_qact.c qf_qeq.c qf_qmact.c qf_time.c
    ../../../src/qs/: qutest.c
    ../../../include/: qpc.h qstamp.c
  group QP_port
    ../../../ports/arm-cm/qv/armclang/: qep_port.h qf_port.h qs_port.h qv_port.c qv_port.h
    ../target_nucleo-l053r8/: qutest_port.c
  group nucleo-l053r8
    ../../../3rd_party/nucleo-l053r8/: stm32l0xx.h stm32l053xx.h system_stm32l0xx.c system_stm32l0xx.h
    ../../../3rd_party/nucleo-l053r8/arm/: startup_stm32l053xx.s
  group QS
    ../../../src/qs/: qs_rx.c qs_fp.c qs_64bit.c qs.c
    ../../../include/: qs_pkg.h qs.h
